Commit message: Changed InertiaParameters

File: urdf/mini_cheetah_simple_correctedInertia.urdf (robot description, URDF)
Before this commit: robot mini_cheetah, 17 links, 16 joints
Links:
- link body: mass 3.3 -> 4.79
